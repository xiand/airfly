# Keil uVision project Nucleof411re-std.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleof411re-std +hex
  AfterMake: fromelf.exe -bin -o   ./Objects/output.bin  ./Objects/Nucleof411re-std.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\..\USER\bsp_nucleof411Re;..\..\USER\bsp_nucleof411Re\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\USER\IAP;..\..\USER\FatFS\src;..\..\Freertos\include;..\..\Freertos\portable\RVDS\ARM_CM4F;..\..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../USER/: main.c FreeRTOSConfig.h SysInfoTest.c includes.h demo_sdio_fatfs.c
  group BSP
    ../../USER/bsp_nucleof411Re/: bsp.c stm32f4xx_assert.c stm32f4xx_it.c
    ../../USER/bsp_nucleof411Re/src/: bsp_DwtDelay.c bsp_key.c bsp_led.c bsp_myDs18b20.c bsp_SysClock.c bsp_SysTick.c bsp_timer.c bsp_usart_fifo.c bsp_OledShow.c bsp_spiSD.c bsp_tim_pwm.c bsp_rtc.c bsp_sdio_sd.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
  group CMSIS
    ../../USER/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 说明.txt
  group Fatfs
    ../../USER/FatFS/src/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
    ../../USER/FatFS/src/option/: cc936.c
  group IAP
    ../../USER/IAP/: common.c flash_if.c main.c menu.c ymodem.c
  group FreeRTOS/Source
    ../../Freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../Freertos/portable/MemMang/: heap_4.c
    ../../Freertos/portable/RVDS/ARM_CM4F/: port.c portmacro.h
